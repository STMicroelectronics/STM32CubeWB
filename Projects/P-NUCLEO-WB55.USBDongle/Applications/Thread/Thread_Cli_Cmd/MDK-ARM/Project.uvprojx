# Keil uVision project Project.uvprojx, settings and files
target STM32WBxx_USBD_Thread_Cli_Cmd (6190000::V6.19::ARMCLANG)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.4.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000004-0x2002FC03) IRAM2aRet_SHARED(0x20030000-0x200327FF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: ENABLE_OPENTHREAD_CLI,MBEDTLS_CONFIG_FILE=<mbedtls-config.h>,MBEDTLS_USER_CONFIG_FILE=<stm32wb-mbedtls-config.h>,CORE_CM4,USE_HAL_DRIVER,USE_STM32WBXX_USB_DONGLE,THREAD_WB,STM32WB55xx,ST_OT_DEBUG,OPENTHREAD_CONFIG_FILE=<openthread_api_config_ftd.h>,OPENTHREAD_PROJECT_CORE_CONFIG_FILE=<stm32wb-openthread-ftd-config.h>,WBx_OTLIB_BUILD_IAR_KEIL,__DBG_ITM
  c misc: -Wno-unused-result
  c include: ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../../Drivers/BSP/P-NUCLEO-WB55.USBDongle/;../Core/Inc;../STM32_WPAN/App;../STM32_WPAN/Target;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/core/mbedtls_config;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/core/openthread_api;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/core/openthread_config;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/examples/platforms;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/examples/platforms/utils;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/include;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/include/openthread;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/include/openthread/platform;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/cli;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/config,../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/include,../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/include;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/diag;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/mbedtls;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/mbedtls/repo/configs;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/mbedtls/repo/include;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/mbedtls/repo/include/mbedtls;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/wbx_include;..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\thread\openthread\stack\wbx_include\sys;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Utilities/sequencer;../../../../../../Middlewares/ST/STM32_WPAN;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/vcp;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/mbedtls/repo/include;..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\utilities
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000004 size 0x2fc00
  scatter file: .\stm32wb55xx_flash_cm4.sct
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core/src
    ../Core/Src/: app_entry.c stm32_lpm_if.c hw_timerserver.c hw_uart.c main.c stm32wbxx_it.c stm_logging.c system_stm32wbxx.c stm32wbxx_hal_msp.c
    ./: Retarget.c Serial.c
  group Application/User/STM32_WPAN/app
    ../STM32_WPAN/App/: app_thread.c
  group Application/User/STM32_WPAN/target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/P-NUCLEO-WB55.USBDongle
    ../../../../../../Drivers/BSP/P-NUCLEO-WB55.USBDongle/: stm32wbxx_usb_dongle.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_ll_usb.c stm32wbxx_hal_pcd.c stm32wbxx_hal_pcd_ex.c stm32wbxx_hal_hsem.c
  group Middlewares/STM32_USB_Device_Library/Class/CDC
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/STM32_USB_Device_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/shci
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/tl
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: shci_tl.c shci_tl_if.c tl_mbox.c tl_thread_hci.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/vcp
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/vcp/: usbd_conf.c usbd_desc.c vcp.c
  group openthread/core/openthread_api
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/core/openthread_api/: backbone_router.c backbone_router_ftd.c border_agent.c border_router.c border_routing.c channel_manager.c channel_monitor.c child_supervision.c cli_platform.c coap.c coap_secure.c commissioner.c crypto.c dataset.c dataset_ftd.c dataset_updater.c diag.c dns.c dns_server.c entropy.c errors.c heap.c history_tracker.c icmp6.c instance.c ip6.c jam_detection.c joiner.c link.c link_metrics.c link_raw.c logging.c mesh_diag.c message.c multi_radio.c nat64.c netdata.c netdata_publisher.c netdiag.c network_time.c openthread.c openthread_api_wb.c ping_sender.c radio.c random_crypto.c random_noncrypto.c server.c sntp.c srp_client.c srp_client_buffers.c srp_server.c tasklet.c tcp.c tcp_ext.c thread.c thread_ftd.c trel.c udp.c
  group openthread/stack/examples/apps/cli
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/examples/apps/cli/: cli_uart.cpp
  group openthread/stack/examples/platforms/utils
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/examples/platforms/utils/: debug_uart.c link_metrics_renamed.cpp mac_frame_renamed.cpp soft_source_match_table.c
  group openthread/stack/src/cli
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/cli/: cli_bbr.cpp cli.cpp cli_coap.cpp cli_coap_secure.cpp cli_commissioner.cpp cli_dataset.cpp cli_dns.cpp cli_history.cpp cli_joiner.cpp cli_link_metrics.cpp cli_mac_filter.cpp cli_mesh_diag.cpp cli_network_data.cpp cli_ping.cpp cli_srp_client.cpp cli_srp_server.cpp cli_tcp.cpp cli_udp.cpp cli_utils.cpp
  group openthread/stack/src/core/backbone_router
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/backbone_router/: backbone_tmf.cpp bbr_leader.cpp bbr_local.cpp bbr_manager.cpp multicast_listeners_table.cpp ndproxy_table.cpp
  group openthread/stack/src/core/border_router
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/border_router/: routing_manager.cpp
  group openthread/stack/src/core/coap
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/coap/: coap.cpp coap_message.cpp coap_secure.cpp
  group openthread/stack/src/core/common
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/common/: appender.cpp binary_search.cpp bit_utils.cpp data.cpp error.cpp frame_builder.cpp frame_data.cpp heap_data.cpp heap_renamed.cpp heap_string.cpp log.cpp message.cpp notifier.cpp preference.cpp random.cpp settings.cpp string.cpp tasklet.cpp time_ticker.cpp timer.cpp tlvs.cpp trickle_timer.cpp uptime.cpp crc.cpp offset_range.cpp
  group openthread/stack/src/core/crypto
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/crypto/: aes_ccm.cpp aes_ecb.cpp crypto_platform_mbedtls.cpp crypto_platform_psa.cpp hkdf_sha256.cpp hmac_sha256.cpp mbedtls.cpp sha256.cpp storage.cpp
  group openthread/stack/src/core/diags
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/diags/: factory_diags.cpp
  group openthread/stack/src/core/instance
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/instance/: instance.cpp
  group openthread/stack/src/core/mac
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/mac/: channel_mask.cpp data_poll_handler.cpp data_poll_sender.cpp link_raw.cpp mac.cpp mac_filter.cpp mac_frame.cpp mac_links.cpp mac_types.cpp sub_mac.cpp sub_mac_callbacks.cpp mac_header_ie.cpp scan_result.cpp sub_mac_csl_receiver.cpp sub_mac_wed.cpp wakeup_tx_scheduler.cpp
  group openthread/stack/src/core/meshcop
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/meshcop/: announce_begin_client.cpp border_agent.cpp commissioner.cpp dataset.cpp dataset_manager.cpp dataset_manager_ftd.cpp dataset_updater.cpp energy_scan_client.cpp extended_panid.cpp joiner.cpp joiner_router.cpp meshcop.cpp meshcop_leader.cpp meshcop_tlvs.cpp network_identity.cpp network_name.cpp panid_query_client.cpp secure_transport.cpp seeker.cpp steering_data.cpp timestamp.cpp tcat_agent.cpp
  group openthread/stack/src/core/net
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/net/: checksum.cpp dhcp6_client.cpp dhcp6_server.cpp dns_client.cpp dns_dso.cpp dns_types.cpp dnssd_server.cpp icmp6.cpp ip4_types.cpp ip6.cpp ip6_address.cpp ip6_filter.cpp ip6_headers.cpp ip6_mpl.cpp nat64_translator.cpp nd_agent.cpp nd6.cpp netif.cpp slaac_address.cpp sntp_client.cpp socket.cpp srp_client.cpp srp_server.cpp tcp6.cpp tcp6_ext.cpp udp6.cpp dhcp6_types.cpp
  group openthread/stack/src/core/radio
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/radio/: radio.cpp radio_callbacks.cpp radio_platform.cpp trel_interface.cpp trel_link.cpp trel_packet.cpp
  group openthread/stack/src/core/thread
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/thread/: address_resolver.cpp announce_begin_server.cpp announce_sender.cpp anycast_locator.cpp child.cpp child_supervision.cpp child_table.cpp csl_tx_scheduler.cpp discover_scanner.cpp dua_manager.cpp energy_scan_server.cpp indirect_sender.cpp key_manager.cpp link_metrics.cpp link_metrics_types.cpp link_quality.cpp lowpan.cpp mesh_forwarder.cpp mesh_forwarder_ftd.cpp mesh_forwarder_mtd.cpp mle.cpp mle_tlvs.cpp mle_types.cpp mlr_manager.cpp message_framer.cpp neighbor.cpp neighbor_table.cpp network_data.cpp network_data_leader.cpp network_data_leader_ftd.cpp network_data_local.cpp network_data_notifier.cpp network_data_publisher.cpp network_data_service.cpp network_data_tlvs.cpp network_data_types.cpp network_diagnostic.cpp network_diagnostic_tlvs.cpp panid_query_server.cpp radio_selector.cpp router.cpp router_table.cpp src_match_controller.cpp thread_netif.cpp time_sync_service.cpp tmf.cpp uri_paths.cpp mle_ftd.cpp thread_link_info.cpp vendor_info.cpp version.cpp
  group openthread/stack/src/core/utils
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/utils/: channel_manager.cpp channel_monitor.cpp flash.cpp heap.cpp history_tracker.cpp jam_detector.cpp mesh_diag.cpp otns.cpp parse_cmdline.cpp ping_sender.cpp power_calibration.cpp srp_client_buffers.cpp
  group openthread/stack/third_party/mbedtls/repo/library
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/mbedtls/repo/library/: aes.c aesni.c aria.c asn1parse.c asn1write.c base64.c bignum.c bignum_core.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa_renamed.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error_renamed.c gcm.c hkdf.c hmac_drbg.c md.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_ecc.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c sha1.c sha256_renamed.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_client.c ssl_cookie.c ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_keys.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c
  group openthread/stack/third_party/tcplp/bsdtcp
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/tcplp/bsdtcp/: tcp_fastopen.c tcp_input.c tcp_output.c tcp_reass.c tcp_sack.c tcp_subr.c tcp_timer.c tcp_timewait.c tcp_usrreq.c
  group openthread/stack/third_party/tcplp/bsdtcp/cc
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/tcplp/bsdtcp/cc/: cc_newreno.c
  group openthread/stack/third_party/tcplp/lib
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/tcplp/lib/: bitmap.c cbuf.c lbuf.c
  group Middlewares/STM32_WPAN/utilities
    ../../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c advanced_memory_manager.c stm32_mm.c
  group Utilities
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
software components: CMSIS:CORE 5.6.0
