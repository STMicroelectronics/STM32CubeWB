# IAR project Project.ewp, settings and files
configuration STM32WBxx_USBD_Thread_Cli_Cmd (ARM)
  General.OGChipSelectEditMenu: STM32WB55RG ST STM32WB55RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; USE_STM32WBXX_USB_DONGLE; THREAD_WB; STM32WB55xx; ST_OT_DEBUG; OPENTHREAD_CONFIG_FILE=<openthread_api_config_ftd.h>; OPENTHREAD_PROJECT_CORE_CONFIG_FILE=<stm32wb-openthread-ftd-config.h>; MBEDTLS_CONFIG_FILE=<mbedtls-config.h>; MBEDTLS_USER_CONFIG_FILE=<stm32wb-mbedtls-config.h>; ENABLE_OPENTHREAD_CLI
  ICCARM.CCIncludePath2: ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../../../../../../Drivers/BSP/P-NUCLEO-WB55.USBDongle; ../Core/Inc; ../STM32_WPAN/App; ../STM32_WPAN/Target; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Utilities/sequencer; ../../../../../../Middlewares/ST/STM32_WPAN; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/include; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/include/openthread; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/core/openthread_api; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/core/openthread_config; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/core/mbedtls_config; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread; ../../../../../../Middlewares/ST/STM32_WPAN/utilities; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/vcp; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/include/openthread/platform; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/mbedtls/repo/include; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/mbedtls/repo/include/mbedtls; ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/config; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/cli; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/examples/platforms; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/examples/platforms/utils; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/mbedtls; ../../../../../../Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ../../../../../../Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: Thread_Cli_Cmd.bin
  ILINK.IlinkOutputFile: Thread_Cli_cmd.out
  ILINK.IlinkIcfFile: stm32wb55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core/src
    ../Core/Src/: app_entry.c hw_timerserver.c hw_uart.c main.c stm32_lpm_if.c stm32wbxx_hal_msp.c stm32wbxx_it.c stm_logging.c system_stm32wbxx.c
  group Application/User/STM32_WPAN/app
    ../STM32_WPAN/App/: app_thread.c
  group Application/User/STM32_WPAN/target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/P-NUCLEO-WB55.USBDongle
    ../../../../../../Drivers/BSP/P-NUCLEO-WB55.USBDongle/: stm32wbxx_usb_dongle.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_pcd.c stm32wbxx_hal_pcd_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_ll_usb.c
  group Middlewares/STM32_USB_Device_Library/Class/CDC
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/STM32_USB_Device_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/shci
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/tl
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: shci_tl.c shci_tl_if.c tl_mbox.c tl_thread_hci.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/vcp
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/vcp/: usbd_conf.c usbd_desc.c vcp.c
  group Middlewares/STM32_WPAN/thread/openthread/core/openthread_api
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/core/openthread_api/: backbone_router.c backbone_router_ftd.c border_agent.c border_router.c channel_manager.c channel_monitor.c child_supervision.c cli_platform.c coap.c coap_secure.c commissioner.c crypto.c dataset.c dataset_ftd.c dataset_updater.c diag.c dns.c dns_server.c entropy.c errors.c heap.c history_tracker.c icmp6.c instance.c ip6.c jam_detection.c joiner.c link.c link_metrics.c link_raw.c logging.c mesh_diag.c message.c multi_radio.c nat64.c netdata.c netdata_publisher.c netdiag.c network_time.c openthread.c openthread_api_wb.c ping_sender.c radio.c random_crypto.c random_noncrypto.c server.c sntp.c srp_client.c srp_client_buffers.c srp_server.c tasklet.c tcp.c tcp_ext.c thread.c thread_ftd.c udp.c
  group Middlewares/STM32_WPAN/thread/openthread/stack/examples/apps/cli
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/examples/apps/cli/: cli_uart.cpp
  group Middlewares/STM32_WPAN/thread/openthread/stack/src/cli
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/cli/: cli.cpp cli_bbr.cpp cli_coap.cpp cli_coap_secure.cpp cli_commissioner.cpp cli_dataset.cpp cli_dns.cpp cli_joiner.cpp cli_link_metrics.cpp cli_mac_filter.cpp cli_mesh_diag.cpp cli_network_data.cpp cli_ping.cpp cli_srp_client.cpp cli_tcp.cpp cli_udp.cpp cli_utils.cpp
  group Middlewares/STM32_WPAN/thread/openthread/stack/src/core/common
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/common/: binary_search.cpp string.cpp timer.cpp tlvs.cpp
  group Middlewares/STM32_WPAN/thread/openthread/stack/src/core/crypto
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/crypto/: crypto_platform_mbedtls.cpp crypto_platform_psa.cpp mbedtls.cpp
  group Middlewares/STM32_WPAN/thread/openthread/stack/src/core/instance
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/instance/: instance.cpp
  group Middlewares/STM32_WPAN/thread/openthread/stack/src/core/meshcop
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/meshcop/: dataset.cpp meshcop_tlvs.cpp network_name.cpp timestamp.cpp
  group Middlewares/STM32_WPAN/thread/openthread/stack/src/core/thread
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/thread/: key_manager.cpp
  group Middlewares/STM32_WPAN/thread/openthread/stack/src/core/utils
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/utils/: parse_cmdline.cpp
  group Middlewares/STM32_WPAN/thread/openthread/stack/third_party/mbedtls/repo/library
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/mbedtls/repo/library/: aes.c asn1parse.c asn1write.c base64.c bignum.c bignum_core.c ccm.c cipher.c cipher_wrap.c constant_time.c ctr_drbg.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c hmac_drbg.c md.c oid.c pem.c pk.c pk_ecc.c pk_wrap.c pkparse.c platform.c platform_util.c sha256.c ssl_ciphersuites.c ssl_client.c ssl_msg.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c x509.c x509_crt.c
  group Middlewares/STM32_WPAN/utilities
    ../../../../../../Middlewares/ST/STM32_WPAN/utilities/: advanced_memory_manager.c dbg_trace.c otp.c stm_list.c stm_queue.c
  group Utilities
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Middlewares/ST/STM32_WPAN/utilities/: stm32_mm.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
