# IAR project BLE_p2pRouteur.ewp, settings and files
configuration BLE_p2pRouteur (ARM)
  General.OGChipSelectEditMenu: STM32WB55CG ST STM32WB55CG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STM32WBXX_USB_DONGLE; STM32WB55xx; CORE_CM4; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\ble\core\template; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\ble\core\auto; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBxx\Include; ..\..\..\..\..\..\Drivers\STM32WBxx_HAL_Driver\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\ble\core\; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\interface\patterns\ble_thread\tl; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\utilities; ..\..\..\..\..\..\Utilities\lpm\tiny_lpm; ..\..\..\..\..\..\Utilities\sequencer; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\interface\patterns\ble_thread\shci; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\interface\patterns\ble_thread; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\ble; ..\Core\Inc; ..\STM32_WPAN\app; ..\..\..\..\..\..\Drivers\BSP\P-NUCLEO-WB55.USBDongle; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\interface\patterns\ble_thread\vcp; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\interface\patterns\ble_thread\vcp
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_p2pRouteur.hex
  ILINK.IlinkOutputFile: BLE_p2pRouteur.out
  ILINK.IlinkIcfFile: stm32wb55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Core
    ../Core/Src/: app_debug.c app_entry.c hw_timerserver.c hw_uart.c main.c stm32_lpm_if.c stm32wbxx_hal_msp.c stm32wbxx_it.c
  group Application/EWARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/STM32_WPAN/app
    ../STM32_WPAN/App/: app_ble.c p2p_routeur_app.c
  group Application/STM32_WPAN/target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/P-NUCLEO-WB55.USBDongle
    ../../../../../../Drivers/BSP/P-NUCLEO-WB55.USBDongle/: stm32wbxx_usb_dongle.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_pcd.c stm32wbxx_hal_pcd_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rng.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_ll_usb.c
  group Middlewares/STM32_USB_Device_Library
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/STM32_WPAN/ble/blesvc
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: eds_stm.c p2p_stm.c svc_ctl.c
  group Middlewares/STM32_WPAN/ble/core
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/shci
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/tl
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c tl_mbox.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/vcp
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/vcp/: usbd_conf.c usbd_desc.c vcp.c
  group Middlewares/STM32_WPAN/utilities
    ../../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
  group Utilities
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
