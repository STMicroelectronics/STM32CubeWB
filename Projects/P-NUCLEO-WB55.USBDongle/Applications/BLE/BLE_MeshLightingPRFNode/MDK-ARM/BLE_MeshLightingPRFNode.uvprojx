# Keil uVision project BLE_MeshLightingPRFNode.uvprojx, settings and files
target BLE_MeshLightingPRFNode (6190000::V6.19::ARMCLANG)
  device: STM32WB55CGUx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.1
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000004-0x2002FC03) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: BLE_MeshLightingPRFNode +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STM32WBXX_USB_DONGLE,STM32WB55xx,USE_HAL_DRIVER,CORE_CM4,STM32,ENABLE_USART,TRACE_ENABLE_NO_FUNCTION,SERVER
  c misc: -Wno-format
  c include: ../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../../../Drivers/BSP/P-NUCLEO-WB55.USBDongle;../../../../../../Middlewares/ST/STM32_WPAN/ble/mesh/Inc;../Core/Inc;../../../../../../Middlewares/ST/STM32_WPAN;../../../../../../Middlewares/ST/STM32_WPAN/ble/core/auto;../../../../../../Middlewares/ST/STM32_WPAN/utilities;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Utilities/sequencer;../../../../../../Middlewares/ST/STM32_WPAN/ble/core/template;../../../../../../Middlewares/ST/STM32_WPAN/ble/core/;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci;../../../../../../Middlewares/ST/STM32_WPAN/ble/mesh/MeshModel/Inc;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread;../STM32_WPAN/app;../../../../../../Middlewares/ST/STM32_WPAN/ble;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/vcp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000004 size 0x2fc00
  scatter file: stm32wb55xx_flash_cm4.sct
  group Application/Core
    ../Core/Src/: app_debug.c app_entry.c hw_timerserver.c hw_uart.c lp_timer.c main.c stm32_lpm_if.c stm32wbxx_it.c flash_driver.c stm32wbxx_hal_msp.c
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/STM32_WPAN/app
    ../STM32_WPAN/app/: app_ble.c appli_generic.c appli_light.c appli_light_lc.c appli_mesh.c appli_nvm.c appli_sensor.c appli_vendor.c models_if.c pal_nvm.c appli_generic_client.c appli_light_client.c appli_sensors_client.c appli_config.c appli_config_client.c
  group Application/STM32_WPAN/target
    ../STM32_WPAN/target/: hw_ipcc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/P-NUCLEO-WB55.USBDongle
    ../../../../../../Drivers/BSP/P-NUCLEO-WB55.USBDongle/: stm32wbxx_usb_dongle.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_pcd.c stm32wbxx_hal_pcd_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_ll_usb.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_hsem.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_rng.c
  group Middlewares/STM32_USB_Device_Library
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/STM32_WPAN/ble/blesvc
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/mesh/MeshModel/Src/: common.c generic.c light.c light_lc.c sensors.c time_scene.c vendor.c generic_client.c light_client.c sensors_client.c config_client.c
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: mesh.c svc_ctl.c
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/mesh/Src/: mesh_cfg.c
  group Middlewares/STM32_WPAN/ble/core
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/shci
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/tl
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c tl_mbox.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/vcp
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/vcp/: usbd_conf.c usbd_desc.c vcp.c
  group Middlewares/STM32_WPAN/utilities
    ../../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
  group Middlewares/ST/STM32_WPAN/ble/mesh/Library
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/mesh/Library/: libBle_Mesh_CM4_Keil.lib
software components: CMSIS:CORE 5.6.0
