<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\PKA_ECDSA_Verify_IT.ewp</path>
  </project>
  <batchBuild />
</workspace>
