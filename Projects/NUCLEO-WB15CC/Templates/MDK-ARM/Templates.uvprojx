# Keil uVision project Templates.uvprojx, settings and files
target Templates (6190000::V6.19::ARMCLANG)
  device: STM32WB15CCUx STMicroelectronics
  pack: Keil.STM32WB1x_DFP.0.0.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x804FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Templates +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WB15xx
  c misc: -Wno-format
  c include: ../Inc;../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy;../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: stm32wb15xx_flash_cm4.sct
  link misc: --diag-suppress  L6314W
  group Application/MDK-ARM
    ./: startup_stm32wb15xx_cm4.s
  group Application/User
    ../Src/: main.c stm32wbxx_it.c stm32wbxx_hal_msp.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
software components: CMSIS:CORE 5.4.0
