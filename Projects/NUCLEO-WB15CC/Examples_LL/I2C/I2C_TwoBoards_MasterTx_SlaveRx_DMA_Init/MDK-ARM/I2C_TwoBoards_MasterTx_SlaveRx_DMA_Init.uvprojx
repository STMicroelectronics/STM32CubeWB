# Keil uVision project I2C_TwoBoards_MasterTx_SlaveRx_DMA_Init.uvprojx, settings and files
target I2C_TwoBoards_MasterTx_SlaveRx_DMA_Init (6190000::V6.19::ARMCLANG)
  device: STM32WB15CCUx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x804FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: I2C_TwoBoards_MasterTx_SlaveRx_DMA_Init +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=4800000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32WB15xx
  c include: ../Inc;../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: stm32wb15xx_flash_cm4.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wb15xx_cm4.s
  group Application/User
    ../Src/: main.c stm32wbxx_it.c
  group Doc
    ../: readme.txt
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_ll_utils.c stm32wbxx_ll_exti.c stm32wbxx_ll_gpio.c stm32wbxx_ll_dma.c stm32wbxx_ll_i2c.c stm32wbxx_ll_pwr.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
software components: CMSIS:CORE 5.6.0
