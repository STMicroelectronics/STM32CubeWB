# IAR project BLE_MeshLightingPRFNode.ewp, settings and files
configuration Lighting_PRF_Node (ARM)
  General.OGChipSelectEditMenu: STM32WB15CC ST STM32WB15CC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STM32WBXX_NUCLEO; USE_HAL_DRIVER; STM32WB15xx; ENABLE_USART
  ICCARM.CCIncludePath2: ../Core/Inc; ../STM32_WPAN/app; ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../../../../../../Middlewares/ST/STM32_WPAN; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci; ../../../../../../Middlewares/ST/STM32_WPAN/utilities; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Utilities/sequencer; ../../../../../../Middlewares/ST/STM32_WPAN/ble; ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/template; ../../../../../../Middlewares/ST/STM32_WPAN/ble/core; ../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/NUCLEO-WB15CC; ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/auto; ../../../../../../Middlewares/ST/STM32_WPAN/ble/mesh/Inc; ../../../../../../Middlewares/ST/STM32_WPAN/ble/mesh/MeshModel/Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_MeshLightingPRFNode.hex
  ILINK.IlinkOutputFile: BLE_MeshLightingPRFNode.out
  ILINK.IlinkIcfFile: stm32wb15xx_flash_cm4.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\ble\mesh\Library\libBle_Mesh_CM4_WB15xx_IAR.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb15xx_cm4.s
  group Application/User/Core
    ../Core/Src/: app_debug.c app_entry.c flash_driver.c hw_timerserver.c hw_uart.c lp_timer.c main.c standby.c stm32_lpm_if.c stm32wbxx_hal_msp.c stm32wbxx_it.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/app/: app_ble.c appli_config.c appli_generic.c appli_light.c appli_light_lc.c appli_mesh.c appli_nvm.c appli_sensor.c appli_vendor.c models_if.c pal_nvm.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/target/: hw_ipcc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/NUCLEO-WB15CC
    ../../../../../../Drivers/BSP/NUCLEO-WB15CC/: nucleo_wb15cc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rng.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c
  group Middlewares/STM32_WPAN
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/mesh/MeshModel/Src/: common.c generic.c light.c light_lc.c sensors.c vendor.c
    ../../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c tl_mbox.c
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: mesh.c svc_ctl.c
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/mesh/Src/: mesh_cfg.c
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
  group Utilities
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
