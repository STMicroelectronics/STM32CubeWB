# Keil uVision project BLE_MeshLightingDemoPRFNode.uvprojx, settings and files
target Lighting_PRFNode (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32WB15CCUx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00003000) IRAM2(0x20030000,0x00009000) IROM(0x08000000,0x00050000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: BLE_MeshLightingPRFNodeDemo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM32WBXX_NUCLEO,USE_HAL_DRIVER,STM32WB15xx,ENABLE_USART
  c include: ../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../../../Drivers/BSP/NUCLEO-WB15CC;../../../../../../Middlewares/ST/STM32_WPAN/ble/mesh/Inc;../Core/Inc;../../../../../../Middlewares/ST/STM32_WPAN;../../../../../../Middlewares/ST/STM32_WPAN/ble/core/auto;../../../../../../Middlewares/ST/STM32_WPAN/utilities;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Utilities/sequencer;../../../../../../Middlewares/ST/STM32_WPAN/ble/core/template;../../../../../../Middlewares/ST/STM32_WPAN/ble/core/;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci;../../../../../../Middlewares/ST/STM32_WPAN/ble/mesh/MeshModel/Inc;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread;../STM32_WPAN/app;../../../../../../Middlewares/ST/STM32_WPAN/ble
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x21800
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x20030000 size 0x2800
  scatter file: .\stm32wb15xx_flash_cm4.sct
  group Application/Core
    ../Core/Src/: app_debug.c app_entry.c hw_timerserver.c hw_uart.c lp_timer.c main.c stm32_lpm_if.c stm32wbxx_it.c flash_driver.c stm32wbxx_hal_msp.c standby.c
  group Application/MDK-ARM
    ./: startup_stm32wb15xx_cm4.s
  group Application/STM32_WPAN/app
    ../STM32_WPAN/app/: app_ble.c appli_generic.c appli_light.c appli_light_lc.c appli_mesh.c appli_nvm.c appli_sensor.c models_if.c pal_nvm.c appli_config.c appli_vendor.c
  group Application/STM32_WPAN/target
    ../STM32_WPAN/target/: hw_ipcc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/P-NUCLEO-WB55.Nucleo
    ../../../../../../Drivers/BSP/NUCLEO-WB15CC/: nucleo_wb15cc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_hsem.c stm32wbxx_hal_exti.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_rng.c
  group Middlewares/STM32_WPAN/ble/blesvc
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/mesh/MeshModel/Src/: common.c generic.c light.c light_lc.c sensors.c vendor.c
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: mesh.c svc_ctl.c
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/mesh/Src/: mesh_cfg.c
  group Middlewares/STM32_WPAN/ble/core
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/shci
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/tl
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c tl_mbox.c
  group Middlewares/STM32_WPAN/utilities
    ../../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
  group Middlewares/ST/STM32_WPAN/ble/mesh/Library
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/mesh/Library/: libBle_Mesh_CM4_WB15xx_Keil.lib
software components: CMSIS:CORE 5.4.0
