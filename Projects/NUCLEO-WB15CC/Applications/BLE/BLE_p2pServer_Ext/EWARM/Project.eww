<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BLE_p2pServer_Ext.ewp</path>
  </project>
  <batchBuild />
</workspace>
