# Keil uVision project Templates_LL.uvprojx, settings and files
target Templates_LL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32WB1MMCHx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.1
  cpu: IROM(0x08000000-0x801B7FF) IRAM(0x20000008-0x20002C07) IRAM2(0x20030000-0x200327FF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Templates_LL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=32000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNALSAI1_CLOCK_VALUE=2097000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32WB5Mxx
  c include: ../Inc;../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x1b800
  memory RVCT9: RAM 0x20000008 size 0x2ff8
  memory RVCT10: RAM 0x20030000 size 0x2800
  scatter file: stm32wb1mxx_flash_cm4.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wb1mxx_cm4.s
  group Application/User
    ../Src/: main.c stm32wbxx_it.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_ll_exti.c stm32wbxx_ll_gpio.c stm32wbxx_ll_pwr.c stm32wbxx_ll_utils.c
software components: CMSIS:CORE 4.3.0
