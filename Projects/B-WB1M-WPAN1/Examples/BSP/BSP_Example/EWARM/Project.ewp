# IAR project Project.ewp, settings and files
configuration B-WB1M-WPAN1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB1MMC ST STM32WB1MMC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32WB1Mxx; USE_HAL_DRIVER; CORE_CM4
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBxx\Include; ..\..\..\..\..\..\Drivers\STM32WBxx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\B-WB1M-WPAN1; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\ism330dhcx; ..\..\..\..\..\..\Drivers\BSP\Components\stts22h
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BSP.hex
  ILINK.IlinkOutputFile: RCC_ClockConfig.out
  ILINK.IlinkIcfFile: stm32wb1mxx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-WB1M-WPAN1
    ../../../../../../Drivers/BSP/B-WB1M-WPAN1/: b_wb1m_wpan1.c b_wb1m_wpan1_bus.c b_wb1m_wpan1_eeprom.c b_wb1m_wpan1_env_sensors.c b_wb1m_wpan1_env_sensors_ex.c b_wb1m_wpan1_motion_sensors.c b_wb1m_wpan1_motion_sensors_ex.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
    ../../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c
  group Example/EWARM
    ./: startup_stm32wb1mxx_cm4.s
  group Example/User
    ../Src/: eeprom.c led.c main.c sensors.c stm32wbxx_it.c
