# Keil uVision project Project.uvprojx, settings and files
target B-WB1M-WPAN1 (6190000::V6.19::ARMCLANG)
  device: STM32WB1MMCHx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00003000) IRAM2(0x20030000,0x00009000) IROM(0x08000000,0x00050000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: BSP_Example +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32WB1Mxx,USE_HAL_DRIVER,CORE_CM4,__DBG_ITM
  c misc: -Wno-format
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../../../Drivers/BSP/B-WB1M-WPAN1;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/ism330dhcx;../../../../../../Drivers/BSP/Components/stts22h
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1b800
  memory RVCT9: RAM 0x20000000 size 0x2ff8
  memory RVCT10: RAM 0x20030000 size 0x2800
  scatter file: stm32wb1mxx_flash_cm4.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
--diag_suppress 1296
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-WB1M-WPAN1
    ../../../../../../Drivers/BSP/B-WB1M-WPAN1/: b_wb1m_wpan1.c b_wb1m_wpan1_bus.c b_wb1m_wpan1_eeprom.c b_wb1m_wpan1_env_sensors.c b_wb1m_wpan1_env_sensors_ex.c b_wb1m_wpan1_motion_sensors.c b_wb1m_wpan1_motion_sensors_ex.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
    ../../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c
  group Example/MDK-ARM
    ./: startup_stm32wb1mxx_cm4.s
  group Example/User
    ../Src/: eeprom.c led.c main.c sensors.c stm32wbxx_it.c
