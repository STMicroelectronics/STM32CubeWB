# Keil uVision project Templates.uvprojx, settings and files
target Templates (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32WB1MMCHx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.1
  cpu: IROM(0x08000000-0x801B7FF) IRAM(0x20000008-0x20002C07) IRAM2(0x20030000-0x200327FF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Templates +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32WB5Mxx
  c include: ../Inc;../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy;../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../Drivers/CMSIS/Include;../../../../Drivers/BSP/B-WB1M-WPAN1
  memory RVCT4: ROM 0x8000000 size 0x1b800
  memory RVCT9: RAM 0x20000008 size 0x2ff8
  memory RVCT10: RAM 0x20030000 size 0x2800
  scatter file: stm32wb1mxx_flash_cm4.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wb1mxx_cm4.s
  group Application/User
    ../Src/: main.c stm32wbxx_hal_msp.c stm32wbxx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-WB1M-WPAN1
    ../../../../Drivers/BSP/B-WB1M-WPAN1/: b_wb1m_wpan1.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c
software components: CMSIS:CORE 4.3.0
