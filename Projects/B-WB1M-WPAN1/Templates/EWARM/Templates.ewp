# IAR project Templates.ewp, settings and files
configuration Templates (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB1MMC ST STM32WB1MMC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WB5Mxx
  ICCARM.CCIncludePath2: ../Inc; ../../../../Drivers/STM32WBxx_HAL_Driver/Inc; ../../../../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../../../../Drivers/CMSIS/Include; ../../../../Drivers/BSP/B-WB1M-WPAN1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Templates.hex
  ILINK.IlinkOutputFile: Templates.out
  ILINK.IlinkIcfFile: stm32wb1mxx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb1mxx_cm4.s
  group Application/User
    ../Src/: main.c stm32wbxx_hal_msp.c stm32wbxx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-WB1M-WPAN1
    ../../../../Drivers/BSP/B-WB1M-WPAN1/: b_wb1m_wpan1.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c
