# IAR project Zigbee_TempMeas_Server_Coord.ewp, settings and files
configuration Zigbee_TempMeas_Server_Coord (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB55RG ST STM32WB55RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WB55xx; ZIGBEE_WB
  ICCARM.IExtraOptions: --diag_suppress Pe111; --diag_suppress Pe188
  ICCARM.CCIncludePath2: ../Core/Inc; ../STM32_WPAN/App; ../../../../../../Drivers/BSP/STM32WB5MM-DK; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../../../../../../Middlewares/ST/STM32_WPAN; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci; ../../../../../../Middlewares/ST/STM32_WPAN/utilities; ../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/core/inc; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/include; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/include/mac; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Utilities/sequencer; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Utilities/LCD; ../../../../../../Drivers/BSP/Components/stts22h
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Zigbee_TempMeas_Coord.bin
  ILINK.IlinkOutputFile: Zigbee_TempMeas_Coord.out
  ILINK.IlinkIcfFile: stm32wb55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: app_entry.c app_stts22h.c hw_timerserver.c hw_uart.c main.c stm32_lpm_if.c stm32wbxx_hal_msp.c stm32wbxx_it.c stm_logging.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_zigbee.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Component/ssdl1315
    ../../../../../../Drivers/BSP/Components/ssd1315/: ssd1315.c ssd1315_reg.c
  group Drivers/BSP/Component/stts22h
    ../../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
  group Drivers/BSP/STM32WB5MM-DK
    ../../../../../../Drivers/BSP/STM32WB5MM-DK/: stm32wb5mm_dk.c stm32wb5mm_dk_bus.c stm32wb5mm_dk_lcd.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/schi
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/tl
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: hci_tl_if.c shci_tl.c shci_tl_if.c tl_mbox.c tl_zigbee_hci.c
  group Middlewares/STM32_WPAN/utilities
    ../../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
  group Middlewares/STM32_WPAN/zigbee/core
    ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/core/src/: zigbee_core_wb.c
  group Middlewares/STM32_WPAN/zigbee/stack
    ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/lib/: stm32wb_zigbee_wb_lib.a
  group Utilities/LCD
    ../../../../../../Utilities/LCD/: stm32_lcd.c
  group Utilities/lpm/tiny_lpm
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
  group Utilities/sequencer
    ../../../../../../Utilities/sequencer/: stm32_seq.c
