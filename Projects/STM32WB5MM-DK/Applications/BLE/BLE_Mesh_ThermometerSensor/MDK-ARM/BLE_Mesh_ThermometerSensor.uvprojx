# Keil uVision project BLE_Mesh_ThermometerSensor.uvprojx, settings and files
target BLE_Mesh_ThermometerSensor (6190000::V6.19::ARMCLANG)
  device: STM32WB5MMGHx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.4.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000008-0x2002FC07) IRAM2(0x20030000-0x200327FF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: BLE_Mesh_ThermometerSensor +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STM32WB5M_DK,STM32WB55xx,USE_HAL_DRIVER,CORE_CM4,STM32,ENABLE_USART,TRACE_ENABLE_NO_FUNCTION,SERVER,THERMOMETER_NODE
  c misc: -Wno-format -Wno-header-guard -Wno-absolute-value
  c include: ../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../../../Middlewares/ST/STM32_WPAN/ble/mesh/Inc;../Core/Inc;../../../../../../Middlewares/ST/STM32_WPAN;../../../../../../Middlewares/ST/STM32_WPAN/ble/core/auto;../../../../../../Middlewares/ST/STM32_WPAN/utilities;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Utilities/sequencer;../../../../../../Middlewares/ST/STM32_WPAN/ble/core/template;../../../../../../Middlewares/ST/STM32_WPAN/ble/core/;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci;../../../../../../Middlewares/ST/STM32_WPAN/ble/mesh/MeshModel/Inc;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread;../STM32_WPAN/app;../../../../../../Middlewares/ST/STM32_WPAN/ble;../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../../Drivers/BSP/Components/ssd1315;../Core/Src/vl53l0x;../../../../../../Drivers/BSP/Components/stts22h;../../../../../../Drivers/BSP/STM32WB5MM-DK;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/LCD;../../../../../../Utilities/Fonts;../../../../../../Drivers/BSP/Components/ism330dhcx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000008 size 0x2fc00
  memory RVCT10: RAM 0x20030000 size 0x2800
  scatter file: stm32wb5mxx_flash_cm4.sct
  link misc: ../../../../../../Middlewares/ST/STM32_WPAN/ble/mesh/Library/libBle_Mesh_CM4_IAR.a

--diag_suppress 1296
  group Application/Core
    ../Core/Src/: app_debug.c app_entry.c app_stts22h.c app_vl53l0x.c hw_timerserver.c hw_uart.c lp_timer.c main.c stm32_lpm_if.c stm32wbxx_it.c flash_driver.c
  group Application/MDK-ARM
    ./: startup_stm32wb5mxx_cm4.s
  group Application/STM32_WPAN/app
    ../STM32_WPAN/app/: app_ble.c appli_config.c appli_config_client.c appli_generic.c appli_generic_client.c appli_light.c appli_light_client.c appli_light_lc.c appli_mesh.c appli_nvm.c appli_sensor.c appli_sensors_client.c appli_vendor.c models_if.c pal_nvm.c
  group Application/STM32_WPAN/target
    ../STM32_WPAN/target/: hw_ipcc.c
  group Application/vl5310x
    ../Core/Src/vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_platform_log.c vl53l0x_tof.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Component/ssdl1315
    ../../../../../../Drivers/BSP/Components/ssd1315/: ssd1315.c ssd1315_reg.c
  group Drivers/BSP/Component/stts22h
    ../../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
  group Drivers/BSP/STM32WB5MM-DK
    ../../../../../../Drivers/BSP/STM32WB5MM-DK/: stm32wb5mm_dk.c stm32wb5mm_dk_bus.c stm32wb5mm_dk_lcd.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_adc_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c
  group Middlewares/STM32_WPAN/ble/blesvc
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/mesh/MeshModel/Src/: common.c config_client.c generic.c generic_client.c light.c light_client.c light_lc.c sensors.c sensors_client.c time_scene.c vendor.c
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: mesh.c svc_ctl.c
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/mesh/Src/: mesh_cfg.c
  group Middlewares/STM32_WPAN/ble/core
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/shci
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/tl
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c tl_mbox.c
  group Middlewares/STM32_WPAN/utilities
    ../../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
  group Utilities/LCD
    ../../../../../../Utilities/LCD/: stm32_lcd.c
  group Middlewares/ST/STM32_WPAN/ble/mesh/Library
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/mesh/Library/: libBle_Mesh_CM4_Keil.lib
software components: CMSIS:CORE 5.6.0
