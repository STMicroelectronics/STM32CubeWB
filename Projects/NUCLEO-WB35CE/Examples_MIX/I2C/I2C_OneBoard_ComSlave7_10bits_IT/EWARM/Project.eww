<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\I2C_OneBoard_ComSlave7_10bits_IT.ewp</path>
  </project>
  <batchBuild />
</workspace>
