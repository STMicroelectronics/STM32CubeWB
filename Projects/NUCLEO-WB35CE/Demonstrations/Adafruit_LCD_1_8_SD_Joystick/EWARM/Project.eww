<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Adafruit_LCD_1_8_SD_Joystick.ewp</path>
  </project>
  <batchBuild />
</workspace>
