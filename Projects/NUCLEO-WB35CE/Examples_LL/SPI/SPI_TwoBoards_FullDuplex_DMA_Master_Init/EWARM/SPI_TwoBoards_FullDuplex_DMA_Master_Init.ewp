# IAR project SPI_TwoBoards_FullDuplex_DMA_Master_Init.ewp, settings and files
configuration SPI_TwoBoards_FullDuplex_DMA_Master_Init (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB35CE ST STM32WB35CE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; HSE_VALUE=8000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; EXTERNAL_CLOCK_VALUE=4800000; HSI_VALUE=16000000; LSI_VALUE=32000; VDD_VALUE=3300; PREFETCH_ENABLE=0; INSTRUCTION_CACHE_ENABLE=1; DATA_CACHE_ENABLE=1; STM32WB35xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPI_TwoBoards_FullDuplex_DMA_Master_Init.hex
  ILINK.IlinkOutputFile: SPI_TwoBoards_FullDuplex_DMA_Master_Init.out
  ILINK.IlinkIcfFile: stm32wb35xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb35xx_cm4.s
  group Application/User
    ../Src/: main.c stm32wbxx_it.c
  group Doc
    ../: readme.txt
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_ll_rcc.c stm32wbxx_ll_utils.c stm32wbxx_ll_exti.c stm32wbxx_ll_gpio.c stm32wbxx_ll_dma.c stm32wbxx_ll_spi.c stm32wbxx_ll_pwr.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
