# Keil uVision project USART_Communication_Rx_IT_Continuous_VCP_Init.uvprojx, settings and files
target USART_Communication_Rx_IT_Continuous_VCP_Init (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.3.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x2002FFFF) IRAM_SHARED(0x20030000-0x20037FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: USART_Communication_Rx_IT_Continuous_VCP_Init +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNALSAI1_CLOCK_VALUE=2097000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32WB55xx,
  c include: ../Inc;../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: .\stm32wb55xx_flash_cm4.sct
  link misc: --diag_suppress L6314W
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User
    ../Src/: main.c stm32wbxx_it.c
  group Doc
    ../: readme.txt
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_ll_utils.c stm32wbxx_ll_exti.c stm32wbxx_ll_gpio.c stm32wbxx_ll_pwr.c stm32wbxx_ll_usart.c stm32wbxx_ll_rcc.c stm32wbxx_ll_dma.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
software components: CMSIS:CORE 4.3.0
