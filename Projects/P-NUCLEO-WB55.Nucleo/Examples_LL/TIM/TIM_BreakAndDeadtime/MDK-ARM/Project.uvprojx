# Keil uVision project Project.uvprojx, settings and files
target STM32WB55RG_Nucleo_TIM_BreakAndDeadtime (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.3.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x2002FFFF) IRAM_SHARED(0x20030000-0x20037FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: STM32WB55xx,USE_FULL_LL_DRIVER
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: .\stm32wb55xx_flash_cm4.sct
  link misc: --diag_suppress L6314W
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32wbxx_it.c
  group Example/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Drivers/STM32WBxx_LL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_ll_utils.c stm32wbxx_ll_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
software components: CMSIS:CORE 4.3.0
