<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\PWR_SMPS_16MHZ_HSI.ewp</path>
  </project>
  <batchBuild />
</workspace>
