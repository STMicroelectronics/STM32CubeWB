# IAR project ble_thread_dyn.ewp, settings and files
configuration no_ota (ARM)
  General.OGChipSelectEditMenu: STM32WB55RG ST STM32WB55RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; USE_STM32WBXX_NUCLEO; STM32WB55xx; ST_OT_DEBUG; OPENTHREAD_CONFIG_FILE=<openthread_api_config_ftd.h>; THREAD_WB; DYNAMIC_MODE
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\STM32WBxx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBxx\Include; ..\..\..\..\..\..\Drivers\BSP\P-NUCLEO-WB55.Nucleo; ..\Core\Inc; ..\STM32_WPAN\App; ..\STM32_WPAN\Target; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\ble\core\template; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\ble\core\auto; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\ble\core\; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\interface\patterns\ble_thread; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\interface\patterns\ble_thread\tl; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\interface\patterns\ble_thread\shci; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\interface\patterns\ble_thread; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\ble; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\utilities; ..\..\..\..\..\..\Utilities\lpm\tiny_lpm; ..\..\..\..\..\..\Utilities\sequencer; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\thread\openthread\stack\include; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\thread\openthread\stack\include\openthread; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\thread\openthread\core\openthread_api; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\thread\openthread; ..\..\..\..\..\..\Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\thread\openthread\stack\third_party\mbedtls\repo\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32wb55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core/src
    ../Core/Src/: app_debug.c app_entry.c hw_timerserver.c hw_uart.c main.c stm32_lpm_if.c stm32wbxx_it.c stm_logging.c
  group Application/User/STM32_WPAN/app
    ../STM32_WPAN/App/: app_ble.c app_thread.c p2p_server_app.c
  group Application/User/STM32_WPAN/target
    ../STM32_WPAN/Target/: hw_ipcc.c
    ../Core/Src/: system_stm32wbxx.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/P-NUCLEO-WB55.Nucleo
    ../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo/: stm32wbxx_nucleo.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c
  group Middlewares/STM32_WPAN/ble/blesvc
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: p2p_stm.c svc_ctl.c
  group Middlewares/STM32_WPAN/ble/core
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/shci
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/tl
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c tl_mbox.c tl_thread_hci.c
  group Middlewares/STM32_WPAN/thread/openthread/core/openthread_api
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/core/openthread_api/: channel_manager.c channel_monitor.c child_supervision.c coap.c coap_secure.c commissioner.c crypto.c dataset.c dataset_ftd.c diag.c dns.c icmp6.c instance.c ip6.c jam_detection.c joiner.c link.c link_raw.c message.c netdata.c network_time.c openthread.c openthread_api_wb.c openthread_api_wb.h radio.c server.c tasklet.c thread.c thread_ftd.c udp.c
  group Middlewares/STM32_WPAN/utilities
    ../../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
  group Utilities
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
