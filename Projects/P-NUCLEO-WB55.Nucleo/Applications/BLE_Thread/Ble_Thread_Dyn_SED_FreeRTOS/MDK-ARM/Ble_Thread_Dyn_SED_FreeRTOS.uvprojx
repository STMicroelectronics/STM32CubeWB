# Keil uVision project Ble_Thread_Dyn_SED_FreeRTOS.uvprojx, settings and files
target P-NUCLEO-WB55.Ble_Thread_Dyn_SED_FreeRTOS (6190000::V6.19::ARMCLANG)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.3.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000004-0x20027C03) IRAM2(0x20030000-0x200327FF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Ble_Thread_Dyn_SED_FreeRTOS
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: MBEDTLS_CONFIG_FILE=<mbedtls-config.h>,MBEDTLS_USER_CONFIG_FILE=<stm32wb-mbedtls-config.h>,OPENTHREAD_CONFIG_FILE=<openthread_api_config_mtd.h>,OPENTHREAD_PROJECT_CORE_CONFIG_FILE=<stm32wb-openthread-mtd-config.h>,USE_HAL_DRIVER,STM32WB55xx,USE_STM32WBXX_NUCLEO,THREAD_WB,WBx_OTLIB_BUILD_IAR_KEIL,DYNAMIC_MODE
  c misc: -Wno-implicit-const-int-float-conversion -Wno-unused-result
  c include: RTE/_P-NUCLEO-WB55.Ble_Thread_Dyn_SED_FreeRTOS;../Core/Inc;../STM32_WPAN/App;../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo;../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/ST/STM32_WPAN;../../../../../../Middlewares/ST/STM32_WPAN/ble;../../../../../../Middlewares/ST/STM32_WPAN/ble/core/;../../../../../../Middlewares/ST/STM32_WPAN/ble/core/auto;../../../../../../Middlewares/ST/STM32_WPAN/ble/core/template;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/core/mbedtls_config;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/core/openthread_api;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/core/openthread_config;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/examples/platforms;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/examples/platforms/utils;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/include;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/include/openthread;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/include/openthread/platform;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/cli;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/config,../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/include,../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/include;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/diag;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/mbedtls;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/mbedtls/repo/configs;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/mbedtls/repo/include;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/mbedtls/repo/include/mbedtls;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/wbx_include;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/wbx_include/sys;../../../../../../Middlewares/ST/STM32_WPAN/utilities;../../../../../../Utilities/lpm/tiny_lpm;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\..\..\..\..\..\Drivers\CMSIS\RTOS2\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000004 size 0x27c00
  memory RVCT10: RAM 0x20030000 size 0x2800
  scatter file: stm32wb55xx_flash_cm4.sct
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core/src
    ../Core/Src/: app_debug.c app_entry.c hw_timerserver.c hw_uart.c main.c stm32_lpm_if.c stm32wbxx_it.c stm_logging.c app_freertos.c freertos_port.c stm32wbxx_hal_msp.c stm32wbxx_hal_timebase_tim.c
  group Application/User/STM32_WPAN/app
    ../STM32_WPAN/App/: app_ble.c app_thread.c p2p_server_app.c
  group Application/User/STM32_WPAN/target
    ../STM32_WPAN/Target/: hw_ipcc.c
    ../Core/Src/: system_stm32wbxx.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/P-NUCLEO-WB55.Nucleo
    ../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo/: stm32wbxx_nucleo.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_exti.c stm32wbxx_hal_gpio.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c
  group Middlewares/STM32_WPAN/ble/blesvc
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: p2p_stm.c svc_ctl.c
  group Middlewares/STM32_WPAN/ble/core
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gen_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/shci
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/tl
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c tl_mbox.c tl_thread_hci.c
  group Middlewares/STM32_WPAN/utilities
    ../../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
  group Utilities
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
  group openthread/core/openthread_api
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/core/openthread_api/: backbone_router.c backbone_router_ftd.c border_agent.c border_router.c border_routing.c channel_manager.c channel_monitor.c child_supervision.c cli_platform.c coap.c coap_secure.c commissioner.c crypto.c dataset.c dataset_ftd.c dataset_updater.c diag.c dns.c dns_server.c entropy.c errors.c heap.c history_tracker.c icmp6.c instance.c ip6.c jam_detection.c joiner.c link.c link_metrics.c link_raw.c logging.c mesh_diag.c message.c multi_radio.c nat64.c netdata.c netdata_publisher.c netdiag.c network_time.c openthread.c openthread_api_wb.c ping_sender.c radio.c random_crypto.c random_noncrypto.c server.c sntp.c srp_client.c srp_client_buffers.c srp_server.c tasklet.c tcp.c tcp_ext.c thread.c thread_ftd.c trel.c udp.c
  group openthread/stack/examples/apps/cli
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/examples/apps/cli/: cli_uart.cpp
  group openthread/stack/examples/platforms/utils
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/examples/platforms/utils/: debug_uart.c link_metrics_renamed.cpp mac_frame_renamed.cpp soft_source_match_table.c
  group openthread/stack/src/cli
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/cli/: cli_bbr.cpp cli.cpp cli_coap.cpp cli_coap_secure.cpp cli_commissioner.cpp cli_dataset.cpp cli_dns.cpp cli_history.cpp cli_joiner.cpp cli_link_metrics.cpp cli_mac_filter.cpp cli_mesh_diag.cpp cli_mesh_diag.cpp cli_network_data.cpp cli_ping.cpp cli_srp_client.cpp cli_srp_server.cpp cli_tcp.cpp cli_udp.cpp cli_utils.cpp
  group openthread/stack/src/core/backbone_router
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/backbone_router/: backbone_tmf.cpp bbr_leader.cpp bbr_local.cpp bbr_manager.cpp multicast_listeners_table.cpp ndproxy_table.cpp
  group openthread/stack/src/core/border_router
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/border_router/: routing_manager.cpp
  group openthread/stack/src/core/coap
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/coap/: coap.cpp coap_message.cpp coap_secure.cpp
  group openthread/stack/src/core/common
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/common/: appender.cpp binary_search.cpp bit_utils.cpp data.cpp error.cpp frame_builder.cpp frame_data.cpp heap_data.cpp heap_renamed.cpp heap_string.cpp log.cpp message.cpp notifier.cpp preference.cpp random.cpp settings.cpp string.cpp tasklet.cpp time_ticker.cpp timer.cpp tlvs.cpp trickle_timer.cpp uptime.cpp crc.cpp offset_range.cpp
  group openthread/stack/src/core/crypto
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/crypto/: aes_ccm.cpp aes_ecb.cpp crypto_platform_mbedtls.cpp crypto_platform_psa.cpp hkdf_sha256.cpp hmac_sha256.cpp mbedtls.cpp sha256.cpp storage.cpp
  group openthread/stack/src/core/diags
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/diags/: factory_diags.cpp
  group openthread/stack/src/core/instance
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/instance/: instance.cpp
  group openthread/stack/src/core/mac
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/mac/: channel_mask.cpp data_poll_handler.cpp data_poll_sender.cpp link_raw.cpp mac.cpp mac_filter.cpp mac_frame.cpp mac_links.cpp mac_types.cpp sub_mac.cpp sub_mac_callbacks.cpp mac_header_ie.cpp scan_result.cpp sub_mac_csl_receiver.cpp sub_mac_wed.cpp wakeup_tx_scheduler.cpp
  group openthread/stack/src/core/meshcop
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/meshcop/: announce_begin_client.cpp border_agent.cpp commissioner.cpp dataset.cpp dataset_manager.cpp dataset_manager_ftd.cpp dataset_updater.cpp energy_scan_client.cpp extended_panid.cpp joiner.cpp joiner_router.cpp meshcop.cpp meshcop_leader.cpp meshcop_tlvs.cpp network_identity.cpp network_name.cpp panid_query_client.cpp secure_transport.cpp seeker.cpp steering_data.cpp timestamp.cpp tcat_agent.cpp
  group openthread/stack/src/core/net
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/net/: checksum.cpp dhcp6_client.cpp dhcp6_server.cpp dns_client.cpp dns_dso.cpp dns_types.cpp dnssd_server.cpp icmp6.cpp ip4_types.cpp ip6.cpp ip6_address.cpp ip6_filter.cpp ip6_headers.cpp ip6_mpl.cpp nat64_translator.cpp nd_agent.cpp nd6.cpp netif.cpp slaac_address.cpp sntp_client.cpp socket.cpp srp_client.cpp srp_server.cpp tcp6.cpp tcp6_ext.cpp udp6.cpp dhcp6_types.cpp
  group openthread/stack/src/core/radio
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/radio/: radio.cpp radio_callbacks.cpp radio_platform.cpp trel_interface.cpp trel_link.cpp trel_packet.cpp
  group openthread/stack/src/core/thread
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/thread/: address_resolver.cpp announce_begin_server.cpp announce_sender.cpp anycast_locator.cpp child.cpp child_supervision.cpp child_table.cpp csl_tx_scheduler.cpp discover_scanner.cpp dua_manager.cpp energy_scan_server.cpp indirect_sender.cpp key_manager.cpp link_metrics.cpp link_metrics_types.cpp link_quality.cpp lowpan.cpp mesh_forwarder.cpp mesh_forwarder_ftd.cpp mesh_forwarder_mtd.cpp mle.cpp mle_tlvs.cpp mle_types.cpp mlr_manager.cpp message_framer.cpp neighbor.cpp neighbor_table.cpp network_data.cpp network_data_leader.cpp network_data_leader_ftd.cpp network_data_local.cpp network_data_notifier.cpp network_data_publisher.cpp network_data_service.cpp network_data_tlvs.cpp network_data_types.cpp network_diagnostic.cpp network_diagnostic_tlvs.cpp panid_query_server.cpp radio_selector.cpp router.cpp router_table.cpp src_match_controller.cpp thread_netif.cpp time_sync_service.cpp tmf.cpp uri_paths.cpp mle_ftd.cpp thread_link_info.cpp vendor_info.cpp version.cpp
  group openthread/stack/src/core/utils
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/utils/: channel_manager.cpp channel_monitor.cpp flash.cpp heap.cpp history_tracker.cpp jam_detector.cpp mesh_diag.cpp otns.cpp parse_cmdline.cpp ping_sender.cpp power_calibration.cpp srp_client_buffers.cpp
  group openthread/stack/third_party/mbedtls/repo/library
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/mbedtls/repo/library/: aes.c aesni.c aria.c asn1parse.c asn1write.c base64.c bignum.c bignum_core.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa_renamed.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error_renamed.c gcm.c hkdf.c hmac_drbg.c md.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_ecc.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c sha1.c sha256_renamed.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_client.c ssl_cookie.c ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_keys.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c
  group openthread/stack/third_party/tcplp/bsdtcp
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/tcplp/bsdtcp/: tcp_fastopen.c tcp_input.c tcp_output.c tcp_reass.c tcp_sack.c tcp_subr.c tcp_timer.c tcp_timewait.c tcp_usrreq.c
  group openthread/stack/third_party/tcplp/bsdtcp/cc
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/tcplp/bsdtcp/cc/: cc_newreno.c
  group openthread/stack/third_party/tcplp/lib
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/tcplp/lib/: bitmap.c cbuf.c lbuf.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
