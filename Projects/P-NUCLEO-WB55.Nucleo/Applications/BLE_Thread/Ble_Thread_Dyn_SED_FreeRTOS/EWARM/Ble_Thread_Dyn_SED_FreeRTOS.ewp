# IAR project Ble_Thread_Dyn_SED_FreeRTOS.ewp, settings and files
configuration Ble_Thread_Dyn_SED_FreeRTOS (ARM)
  General.OGChipSelectEditMenu: STM32WB55RG ST STM32WB55RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; USE_STM32WBXX_NUCLEO; STM32WB55xx; ST_OT_DEBUG; OPENTHREAD_CONFIG_FILE=<openthread_api_config_ftd.h>; OPENTHREAD_PROJECT_CORE_CONFIG_FILE=<stm32wb-openthread-ftd-config.h>; MBEDTLS_CONFIG_FILE=<mbedtls-config.h>; MBEDTLS_USER_CONFIG_FILE=<stm32wb-mbedtls-config.h>; THREAD_WB; DYNAMIC_MODE
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\STM32WBxx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBxx\Include; ..\..\..\..\..\..\Drivers\BSP\P-NUCLEO-WB55.Nucleo; ..\Core\Inc; ..\STM32_WPAN\App; ..\STM32_WPAN\Target; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\ble\core\template; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\ble\core\auto; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\ble\core\; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\interface\patterns\ble_thread; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\interface\patterns\ble_thread\tl; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\interface\patterns\ble_thread\shci; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\interface\patterns\ble_thread; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\ble; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\utilities; ..\..\..\..\..\..\Utilities\lpm\tiny_lpm; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\thread\openthread\stack\include; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\thread\openthread\stack\include\openthread; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\thread\openthread\core\openthread_api; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\thread\openthread\core\openthread_config; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\thread\openthread\core\mbedtls_config; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\thread\openthread; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\thread\openthread\stack\src\core; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\thread\openthread\stack\src\core\config; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\thread\openthread\stack\include\openthread\platform; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\thread\openthread\stack\src\cli; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\thread\openthread\stack\src; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\thread\openthread\stack\examples\platforms; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\thread\openthread\stack\examples\platforms\utils; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\thread\openthread\stack\third_party\mbedtls; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\thread\openthread\stack\third_party\mbedtls\repo\include; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\thread\openthread\stack\third_party\mbedtls\repo\include\mbedtls; ..\..\..\..\..\..\Drivers\CMSIS\RTOS2\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Core\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\..\Drivers\CMSIS\RTOS2\Include
  OBJCOPY.OOCOutputFile: Ble_Thread_Dyn_SED_FreeRTOS.bin
  ILINK.IlinkOutputFile: Ble_Thread_Dyn_SED_FreeRTOS.out
  ILINK.IlinkIcfFile: stm32wb55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core/src
    ../Core/Src/: app_debug.c app_entry.c app_freertos.c freertos_port.c hw_timerserver.c hw_uart.c main.c stm32_lpm_if.c stm32wbxx_hal_msp.c stm32wbxx_hal_timebase_tim.c stm32wbxx_it.c stm_logging.c
  group Application/User/STM32_WPAN/app
    ../STM32_WPAN/App/: app_ble.c app_thread.c p2p_server_app.c
  group Application/User/STM32_WPAN/target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/P-NUCLEO-WB55.Nucleo
    ../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo/: stm32wbxx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/STM32_WPAN/ble/blesvc
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: p2p_stm.c svc_ctl.c
  group Middlewares/STM32_WPAN/ble/core
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_gen_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/shci
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/tl
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c tl_mbox.c tl_thread_hci.c
  group Middlewares/STM32_WPAN/thread/openthread/core/openthread_api
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/core/openthread_api/: backbone_router.c backbone_router_ftd.c border_agent.c border_router.c border_routing.c channel_manager.c channel_monitor.c child_supervision.c cli_platform.c coap.c coap_secure.c commissioner.c crypto.c dataset.c dataset_ftd.c dataset_updater.c diag.c dns.c dns_server.c entropy.c errors.c heap.c history_tracker.c icmp6.c instance.c ip6.c jam_detection.c joiner.c link.c link_metrics.c link_raw.c logging.c mesh_diag.c message.c multi_radio.c nat64.c netdata.c netdata_publisher.c netdiag.c network_time.c openthread.c openthread_api_wb.c ping_sender.c radio.c random_crypto.c random_noncrypto.c server.c sntp.c srp_client.c srp_client_buffers.c srp_server.c tasklet.c tcp.c tcp_ext.c thread.c thread_ftd.c trel.c udp.c
  group Middlewares/STM32_WPAN/thread/openthread/stack/examples/apps/cli
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/examples/apps/cli/: cli_uart.cpp
  group Middlewares/STM32_WPAN/thread/openthread/stack/src/cli
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/cli/: cli.cpp cli_bbr.cpp cli_coap.cpp cli_coap_secure.cpp cli_commissioner.cpp cli_dataset.cpp cli_dns.cpp cli_joiner.cpp cli_link_metrics.cpp cli_mac_filter.cpp cli_network_data.cpp cli_ping.cpp cli_srp_client.cpp cli_tcp.cpp cli_udp.cpp cli_utils.cpp
  group Middlewares/STM32_WPAN/thread/openthread/stack/src/core/common
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/common/: binary_search.cpp instance.cpp string.cpp timer.cpp tlvs.cpp
  group Middlewares/STM32_WPAN/thread/openthread/stack/src/core/crypto
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/crypto/: crypto_platform_mbedtls.cpp crypto_platform_psa.cpp mbedtls.cpp
  group Middlewares/STM32_WPAN/thread/openthread/stack/src/core/instance
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/instance/: instance.cpp
  group Middlewares/STM32_WPAN/thread/openthread/stack/src/core/meshcop
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/meshcop/: dataset.cpp meshcop_tlvs.cpp network_name.cpp timestamp.cpp
  group Middlewares/STM32_WPAN/thread/openthread/stack/src/core/thread
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/thread/: key_manager.cpp
  group Middlewares/STM32_WPAN/thread/openthread/stack/src/core/utils
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/utils/: parse_cmdline.cpp
  group Middlewares/STM32_WPAN/thread/openthread/stack/third_party/mbedtls/repo/library
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/mbedtls/repo/library/: aes.c asn1parse.c asn1write.c base64.c bignum.c bignum_core.c ccm.c cipher.c cipher_wrap.c constant_time.c ctr_drbg.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c hmac_drbg.c md.c oid.c pem.c pk.c pk_ecc.c pk_wrap.c pkparse.c platform.c platform_util.c sha256.c ssl_ciphersuites.c ssl_client.c ssl_msg.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c x509.c x509_crt.c
  group Middlewares/STM32_WPAN/utilities
    ../../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
  group Utilities
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
