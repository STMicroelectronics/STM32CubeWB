<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Ble_Thread_Dyn_SED_FreeRTOS.ewp</path>
    </project>
    <batchBuild />
</workspace>
