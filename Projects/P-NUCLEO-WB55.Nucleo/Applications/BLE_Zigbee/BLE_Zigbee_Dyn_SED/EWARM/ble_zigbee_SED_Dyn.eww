<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ble_zigbee_SED_Dyn.ewp</path>
    </project>
    <batchBuild />
</workspace>
