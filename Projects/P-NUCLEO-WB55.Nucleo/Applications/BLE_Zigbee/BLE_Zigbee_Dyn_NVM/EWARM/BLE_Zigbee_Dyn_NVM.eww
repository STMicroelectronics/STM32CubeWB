<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BLE_Zigbee_Dyn_NVM.ewp</path>
    </project>
    <batchBuild />
</workspace>
