<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Mac_802_15_4_LPM_Periodic_Transmit.ewp</path>
  </project>
  <batchBuild/>
</workspace>


