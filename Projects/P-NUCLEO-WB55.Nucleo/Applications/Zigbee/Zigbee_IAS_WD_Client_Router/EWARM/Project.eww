<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Zigbee_IAS_WD_Client_Router.ewp</path>
    </project>
    <batchBuild />
</workspace>
