<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Zigbee_PowerProfile_Client_Coord.ewp</path>
    </project>
    <batchBuild />
</workspace>
