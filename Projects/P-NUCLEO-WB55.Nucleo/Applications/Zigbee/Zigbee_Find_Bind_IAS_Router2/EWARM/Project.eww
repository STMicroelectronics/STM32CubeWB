<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Zigbee_Find_Bind_IAS_Router2.ewp</path>
    </project>
    <batchBuild />
</workspace>
