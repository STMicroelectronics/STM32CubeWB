<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Zigbee_OnOff_ChannelsAgility_SED.ewp</path>
    </project>
    <batchBuild />
</workspace>
