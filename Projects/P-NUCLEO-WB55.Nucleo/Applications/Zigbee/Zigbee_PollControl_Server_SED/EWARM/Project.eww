<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Zigbee_PollControl_Server_SED.ewp</path>
    </project>
    <batchBuild />
</workspace>
