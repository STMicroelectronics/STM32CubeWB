<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Zigbee_Find_Bind_OnOff_Router1.ewp</path>
    </project>
    <batchBuild />
</workspace>
