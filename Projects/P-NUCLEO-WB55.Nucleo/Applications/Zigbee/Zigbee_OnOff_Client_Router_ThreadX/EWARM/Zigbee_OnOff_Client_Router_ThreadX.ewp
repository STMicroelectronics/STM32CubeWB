# IAR project Zigbee_OnOff_Client_Router_ThreadX.ewp, settings and files
configuration Zigbee_OnOff_Client_Router_ThreadX (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB55RG ST STM32WB55RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WB55xx; USE_STM32WBXX_NUCLEO; ZIGBEE_WB; TX_INCLUDE_USER_DEFINE_FILE; TX_LOW_POWER
  ICCARM.IExtraOptions: --diag_suppress Pe111; --diag_suppress Pe188
  ICCARM.CCIncludePath2: ../Core/Inc; ../STM32_WPAN/App; ../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo; ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../../../../../../Middlewares/ST/STM32_WPAN; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl; ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci; ../../../../../../Middlewares/ST/STM32_WPAN/utilities; ../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/core/inc; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/include; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/include/mac; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/include/extras; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/include/zgp; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/include/zcl; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/include/zcl/key; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/include/zcl/se; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/include/zcl/security; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/include/zcl/general; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/platform; ../../../../../../Middlewares/ST/threadx/common/inc; ../../../../../../Middlewares/ST/threadx/ports/cortex_m4/iar/inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: TX_LOW_POWER
  OBJCOPY.OOCOutputFile: Zigbee_OnOff_Client_Router_ThreadX.bin
  ILINK.IlinkOutputFile: Zigbee_OnOff_Client_Router_ThreadX.out
  ILINK.IlinkIcfFile: stm32wb55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: app_entry.c hw_timerserver.c hw_uart.c main.c stm32_lpm_if.c stm32wbxx_hal_msp.c stm32wbxx_hal_timebase_tim.c stm32wbxx_it.c stm_logging.c tx_initialize_low_level.S
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_zigbee.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32WBxx_Nucleo
    ../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo/: stm32wbxx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c
  group Middlewares/AzureRTOS/threadx/common
    ../../../../../../Middlewares/ST/threadx/common/src/: tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_search.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_get.c tx_semaphore_initialize.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_thread_create.c tx_thread_initialize.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_time_slice.c tx_thread_timeout.c tx_timer_expiration_process.c tx_timer_initialize.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c txe_byte_allocate.c txe_byte_pool_create.c txe_mutex_create.c txe_mutex_get.c txe_mutex_put.c txe_semaphore_create.c txe_semaphore_get.c txe_semaphore_put.c txe_thread_create.c
  group Middlewares/AzureRTOS/threadx/debug_trace
    ../../../../../../Middlewares/ST/threadx/common/src/: tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c
  group Middlewares/AzureRTOS/threadx/ports/cortex_m4/iar/src
    ../../../../../../Middlewares/ST/threadx/ports/cortex_m4/iar/src/: tx_iar.c tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_schedule.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s
  group Middlewares/AzureRTOS/threadx/utility/low_power
    ../../../../../../Middlewares/ST/threadx/utility/low_power/: tx_low_power.c tx_low_power.h
  group Middlewares/STM32_WPAN
    ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/platform/: ee.c hw_flash.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/schi
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/tl
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: hci_tl_if.c shci_tl.c shci_tl_if.c tl_mbox.c tl_zigbee_hci.c
  group Middlewares/STM32_WPAN/utilities
    ../../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
  group Middlewares/STM32_WPAN/zigbee/core
    ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/core/src/: zigbee_core_wb.c
  group Middlewares/STM32_WPAN/zigbee/stack
    ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/lib/: stm32wb_zigbee_wb_lib.a
  group Utilities/lpm/tiny_lpm
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
