<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Zigbee_OnOff_Server_Coord_ThreadX.ewp</path>
    </project>
    <batchBuild />
</workspace>
