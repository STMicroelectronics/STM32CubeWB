<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Zigbee_OnOff_ChannelsAgility_ZC.ewp</path>
    </project>
    <batchBuild />
</workspace>
