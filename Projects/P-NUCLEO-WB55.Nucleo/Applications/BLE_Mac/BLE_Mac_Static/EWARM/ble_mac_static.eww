<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ble_mac_static.ewp</path>
    </project>
    <batchBuild />
</workspace>
