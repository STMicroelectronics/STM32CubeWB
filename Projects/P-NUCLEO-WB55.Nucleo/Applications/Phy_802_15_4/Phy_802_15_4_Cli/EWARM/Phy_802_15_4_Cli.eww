<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Phy_802_15_4_Cli.ewp</path>
  </project>
  <batchBuild />
</workspace>
