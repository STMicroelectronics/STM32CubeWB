<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BLE_Peripheral_Lite_EventCallbacks.ewp</path>
  </project>
  <batchBuild />
</workspace>
