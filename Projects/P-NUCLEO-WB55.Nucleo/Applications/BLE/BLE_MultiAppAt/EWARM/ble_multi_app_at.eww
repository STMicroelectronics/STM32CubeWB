<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ble_multi_app_at.ewp</path>
  </project>
  <batchBuild />
</workspace>
