<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BLE_AT_Server.ewp</path>
  </project>
  <batchBuild />
</workspace>
