<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Thread_Coap_Generic_Ota.ewp</path>
  </project>
  <batchBuild />
</workspace>
