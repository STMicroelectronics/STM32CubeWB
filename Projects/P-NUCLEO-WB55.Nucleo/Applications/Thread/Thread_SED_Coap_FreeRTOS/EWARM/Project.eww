<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Thread_SED_Coap_FreeRTOS.ewp</path>
  </project>
  <batchBuild />
</workspace>
