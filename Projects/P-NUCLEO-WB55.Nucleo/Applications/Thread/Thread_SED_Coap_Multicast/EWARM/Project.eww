<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Thread_SED_Coap_Multicast.ewp</path>
  </project>
  <batchBuild/>
</workspace>


