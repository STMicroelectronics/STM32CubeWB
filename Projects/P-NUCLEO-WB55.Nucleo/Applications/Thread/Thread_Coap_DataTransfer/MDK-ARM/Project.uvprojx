# Keil uVision project Project.uvprojx, settings and files
target STM32WBxx_Nucleo_Thread_Coap_DataTransfer (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx.0.0.7
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000004-0x2002FC03) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_CM4,USE_HAL_DRIVER,USE_STM32WBXX_NUCLEO,THREAD_WB,STM32WB55xx,ST_OT_DEBUG,FRAMEWORK_1,OPENTHREAD_CONFIG_FILE=<openthread_api_config_ftd.h>
  c include: ../../../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo/;../Core/Inc;../STM32_WPAN/App;../STM32_WPAN/Target;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/include;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/include/openthread;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/core/openthread_api;../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread;../../../../../../Middlewares/ST/STM32_WPAN/utilities;../../../../../../Middlewares/ST/STM32_WPAN;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread;../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/vcp;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000004 size 0x2fc00
  scatter file: .\stm32wb55xx_flash_cm4.sct
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core/Src
    ../Core/Src/: app_entry.c hw_lpm.c hw_timerserver.c hw_uart.c main.c stm32wbxx_it.c stm_logging.c system_stm32wbxx.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_thread.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/P-NUCLEO-WB55.Nucleo
    ../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo/: stm32wbxx_nucleo.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_flash.c stm32wbxx_hal_gpio.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_ll_usb.c stm32wbxx_hal_pcd.c stm32wbxx_hal_pcd_ex.c stm32wbxx_hal_adc_ex.c stm32wbxx_hal_adc.c stm32wbxx_hal_flash_ex.c
  group Middlewares/STM32_USB_Device_Library/Class/CDC
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/STM32_USB_Device_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/shci
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/tl
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: shci_tl.c tl_if.c tl_mbox.c tl_thread_hci.c
  group Middlewares/STM32_WPAN/interface/patterns/ble_thread/vcp
    ../../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/vcp/: usbd_conf.c usbd_desc.c vcp.c
  group Middlewares/STM32_WPAN/thread/openthread/core/openthread_api
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/core/openthread_api/: channel_manager.c channel_monitor.c child_supervision.c coap.c commissioner.c crypto.c dataset.c dataset_ftd.c dhcp6_client.c dhcp6_server.c diag.c dns.c icmp6.c instance.c ip6.c jam_detection.c joiner.c link.c link_raw.c message.c netdata.c network_time.cpp openthread.c openthread_api_wb.c server.c tasklet.c thread.c thread_ftd.c udp.c
  group Middlewares/STM32_WPAN/utilities
    ../../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c lpm.c otp.c scheduler.c stm_list.c stm_queue.c
software components: CMSIS:CORE 4.3.0
