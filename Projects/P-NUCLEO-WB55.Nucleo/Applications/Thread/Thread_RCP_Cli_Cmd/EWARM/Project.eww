<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Thread_RCP_Cli_Cmd.ewp</path>
  </project>
  <batchBuild />
</workspace>
