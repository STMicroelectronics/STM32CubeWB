# IAR project Adafruit_LCD_1_8_SD_Joystick.ewp, settings and files
configuration Adafruit_LCD_1_8_SD_Joystick (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB55RG ST STM32WB55RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_STM32WBXX_NUCLEO; USE_HAL_DRIVER; STM32WB55xx
  ICCARM.CCIncludePath2: ../FATFS/Target; ../FATFS/App; ../Core/Inc; ../../../../../Drivers/STM32WBxx_HAL_Driver/Inc; ../../../../../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../../../../../Middlewares/Third_Party/FatFs/src; ../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo; ../../../../../Drivers/BSP/Adafruit_Shield; ../../../../../Drivers/BSP/Components; ../../../../../Drivers/BSP/Components/Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Adafruit_LCD_1_8_SD_Joystick.hex
  ILINK.IlinkOutputFile: Adafruit_LCD_1_8_SD_Joystick.out
  ILINK.IlinkIcfFile: stm32wb55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: main.c stm32wbxx_it.c stm32wbxx_hal_msp.c
  group Application/User/FATFS/App
    ../FATFS/App/: app_fatfs.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: sd_diskio.c
  group Doc
    ../: readme.txt
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_ll_adc.c stm32wbxx_hal_gpio.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c
  group Drivers/BSP/Adafruit_Shield
    ../../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_sd.c stm32_adafruit_lcd.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/st7735/: st7735.c
  group Drivers/BSP/P-NUCLEO-WB55.Nucleo
    ../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo/: stm32wbxx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Middlewares/FatFs
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
