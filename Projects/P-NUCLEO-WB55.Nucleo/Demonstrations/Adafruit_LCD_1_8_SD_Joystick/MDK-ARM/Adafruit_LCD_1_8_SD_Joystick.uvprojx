# Keil uVision project Adafruit_LCD_1_8_SD_Joystick.uvprojx, settings and files
target Adafruit_LCD_1_8_SD_Joystick (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx.0.0.7
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x2002FFFF) IRAM_SHARED(0x20030000-0x20037FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Adafruit_LCD_1_8_SD_Joystick +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM32WBXX_NUCLEO,USE_HAL_DRIVER,STM32WB55xx,
  c include: ../FATFS/Target;../FATFS/App;../Core/Inc;../../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo;../../../../../Drivers/BSP/Adafruit_Shield;../../../../../Drivers/BSP/Components;../../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  scatter file: .\stm32wb55xx_flash_cm4.sct
  link misc: --diag_suppress L6314W
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/FatFs/Target
    ../FATFS/Target/: sd_diskio.c
  group Application/User/FatFs/App
    ../FATFS/App/: app_fatfs.c
  group Application/User/Core
    ../Core/Src/: main.c stm32wbxx_it.c stm32wbxx_hal_msp.c
  group Doc
    ../: readme.txt
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_ll_adc.c stm32wbxx_hal_gpio.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c
  group Drivers/BSP/Adafruit_Shield
    ../../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_sd.c stm32_adafruit_lcd.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/st7735/: st7735.c
  group Drivers/BSP/P-NUCLEO-WB55.Nucleo
    ../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo/: stm32wbxx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Middlewares/FatFs
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
software components: CMSIS:CORE 4.3.0
