<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\HSEM_ReadLock.ewp</path>
  </project>
  <batchBuild />
</workspace>
