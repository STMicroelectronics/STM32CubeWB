# IAR project Project.ewp, settings and files
configuration STM32WB55RG_Nucleo_TIM_OnePulse (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB55RG ST STM32WB55RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32WB55xx; USE_STM32WBXX_NUCLEO; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBxx\Include; ..\..\..\..\..\..\Drivers\STM32WBxx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\P-NUCLEO-WB55.Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32wb55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32wbxx_it.c stm32wbxx_hal_msp.c
  group Example/EWARM
    ./: startup_stm32wb55xx_cm4.s
  group Drivers/BSP/P-NUCLEO-WB55.Nucleo
    ../../../../../../Drivers/BSP/P-NUCLEO-WB55.Nucleo/: stm32wbxx_nucleo.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
