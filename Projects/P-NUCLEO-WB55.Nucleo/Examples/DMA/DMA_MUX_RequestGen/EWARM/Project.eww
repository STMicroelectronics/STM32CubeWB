<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\DMA_MUX_RequestGen.ewp</path>
  </project>
  <batchBuild />
</workspace>
