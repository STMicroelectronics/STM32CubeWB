# Keil uVision project stm32wb_zigbee_mw.uvprojx, settings and files
target standard (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55CCUx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: stm32wb_zigbee_wb_lib_keil (library)
  AfterMake: CMD /C "copy Debug\stm32wb_zigbee_wb_lib_keil.lib .."
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32WB55xx, USE_STM32WBXX_NUCLEO, ZIGBEE_WB, CONFIG_ZCL_OPTIONAL_ATTR_SET
  c misc: --C99 --diag_suppress=188 --diag_suppress=68 --diag_suppress=222 --diag_suppress=1293
  c include: ..\..\stack\include\mac;..\..\stack\include;..\..\core\inc;..\..\stack;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBxx\Include;..\..\..\..\..\..\Drivers\CMSIS\Core\Include;..\..\..\..\..\..\Drivers\STM32WBxx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group zcl
    ../../stack/zcl/: zcl_attr.c zcl_attr_float.c zcl_attr_integer.c zcl_attr_list.c zcl_attr_report.c zcl_attr_string.c zcl_cluster.c zcl_cluster_init.c zcl_command_ind.c zcl_header.c
  group st_custom
    ../../stack/zcl/st_custom/: zcl_custom_ls_client.c zcl_custom_ls_server.c zcl_custom_matrix_client.c zcl_custom_matrix_server.c
  group commission
    ../../stack/zcl/commission/: zcl_commission_client.c zcl_commission_server.c
  group general
    ../../stack/zcl/general/: zcl_alarm_client.c zcl_alarm_server.c zcl_ballast_config_client.c zcl_ballast_config_server.c zcl_basic_client.c zcl_color_client.c zcl_color_server.c zcl_dehum_ctrl_client.c zcl_dehum_ctrl_server.c zcl_device_temp_client.c zcl_device_temp_server.c zcl_diagnostics_client.c zcl_doorlock_client.c zcl_doorlock_server.c zcl_elec_meas_client.c zcl_elec_meas_server.c zcl_fan_client.c zcl_fan_server.c zcl_groups_client.c zcl_groups_server.c zcl_identify_client.c zcl_identify_server.c zcl_illum_level_client.c zcl_illum_level_server.c zcl_illum_meas_client.c zcl_illum_meas_server.c zcl_level_client.c zcl_level_server.c zcl_meter_id_client.c zcl_meter_id_server.c zcl_nearest_gw_client.c zcl_nearest_gw_server.c zcl_occupancy_client.c zcl_occupancy_server.c zcl_onoff_client.c zcl_onoff_server.c zcl_onoff_swconfig_client.c zcl_onoff_swconfig_server.c zcl_ota_client.c zcl_ota_server.c zcl_poll_control_client.c zcl_poll_control_server.c zcl_power_config_client.c zcl_power_config_server.c zcl_power_profile_client.c zcl_power_profile_server.c zcl_press_meas_client.c zcl_press_meas_server.c zcl_pump_client.c zcl_pump_server.c zcl_rssi_loc_client.c zcl_rssi_loc_server.c zcl_scenes_client.c zcl_scenes_server.c zcl_temp_meas_client.c zcl_temp_meas_server.c zcl_therm_client.c zcl_therm_server.c zcl_therm_ui_client.c zcl_therm_ui_server.c zcl_time_client.c zcl_time_server.c zcl_voice_client.c zcl_voice_server.c zcl_water_content_client.c zcl_water_content_server.c zcl_window_client.c zcl_window_server.c
  group se
    ../../stack/zcl/se/: zcl_drlc_client.c zcl_drlc_server.c zcl_messaging_client.c zcl_messaging_server.c zcl_price_client.c zcl_price_server.c zcl_simplemeter_client.c zcl_simplemeter_server.c zcl_tunnel_client.c zcl_tunnel_server.c
  group security
    ../../stack/zcl/security/: zcl_ias_ace_client.c zcl_ias_ace_server.c zcl_ias_wd_client.c zcl_ias_wd_server.c zcl_ias_zone_client.c zcl_ias_zone_server.c
  group pletoh
    ../../stack/: pletoh.c
